# Repository openhwgroup/core-v-mcu-devkit

File README.md:

# core-v-mcu-devkit
The CORE-V MCU DevKit is an evaluation platform for the OpenHW RISC-V CV32E40P core IP (v1.0.0).  More information can be found at the [CV32E40P repo](https://github.com/openhwgroup/cv32e40p0).

## Organization

1. Project Parts - parts not built into kicad required for the devkit
2. kicad - kicad schematics and pcb files
3. images - image files to support this document

## About the devkit

This devkit has the following features:
1. CORE-V MCU (including CV32E40P (v1.0.0) RISC-V core and Quicklogic ArcticPro2 Embedded FPGA)
2. 4MB Flash memory to hold programs and EFPGA bit images
3. Onboard Ashling Opella LD JTAG debugger + Serial Consol interface
4. Offboard JTAG Connector
5. Every signal of the MCU brought out to test pins
6. I2C temperature sensor
7. CSI Camera interface with Himax camera
8. 2 LED's controllable by the MCU or by the EFPGA
9. 1 button for input to the MCU or to the FPGA
10. [mikroBUS](https://www.mikroe.com/mikrobus) socket for system expansion
11. Espressif AWS IoT ExpressLink interface for cloud learning

[PDF Schematic](docs/images/OpenHW%20DevKit.pdf)

## Power
The devkit can be powered from 5 - 18V.  This can be easily accomplished via the 2.1mm DC barrel jack.  The USB-C connector will negotiate 5v from the USB source.

## Voltage levels
The CORE-V-MCU has a 1.8v I/O pad ring.  The 3.3v peripherals are interfaced to the 1.8v MCU with 7 level shifters.  The pins directly around the MCU are connected directly to the MCU pads and will be 1.8v logic.  The QSPI program flash memory is also at 1.8v logic.  The JTAG interface to the Ashling Opella LD is level shifted.  The enable signals on the JTAG level shifters is connected to jumper J4.  Inserting a jumper will disable the level shifters to the on-board JTAG interface allowing the JTAG header to be used.  

> Note: the JTAG header is directly connected to the CORE-V-MCU and will require 1.8v logic.

## mikroBUS
The microBUS header provides a UART, GPIO, I2C and SPI interface.  The UART interface is shared with the AWS IoT ExpressLink.  The CORE-V-MCU has an I/O multiplexer and an alternate pin mode allows the UART interface to be switched between two sets of I/O pins.
The microBUS is fully wired except for the 5v power option.  5v is not available to microBUS so ensure any CLICK's are configured for 3.3v.

## KiCad design OpenHW DevKit.kicad_pcb

Board: 4 copper layers, 100.0 x 75.0 mm, 179 parts (11 on the bottom side), 140 nets.

Parts:
C1, C2, C7, C8, C27, C30: 12.5pF; C_0603_1608Metric
C3, C5, C33, C69, C70, C71: 10uF; C_0603_1608Metric
C4, C6, C9, C12, C13, C14, C15, C16, C17, C18, C19, C20, C24, C25, C28, C29, C31, C34, C40, C41, C45, C48, C49, C50, C55, C57, C59, C61, C63, C65, C68, C72, C73, C74, C84, C85, C86, C87: 100nF; C_0603_1608Metric
C10, C11: 4.7uF; C_0603_1608Metric
C21, C22, C23: 150pF; C_0603_1608Metric
C26: 3.3uF; C_0603_1608Metric
C32, C35: 100n; C_0603_1608Metric
C36, C37: 1uF; C_0603_1608Metric
C75, C76, C77, C78, C79, C80, C81, C82, C83: 22uF; C_0603_1608Metric
CON1: MIKROBUS_HOST_CONN
D1, D2, D4: ESD9B5.0ST5G; D_SOD-923
D3: BAT760-7; SOD2513X120N
D5, D6, D7: LED_Small; LED_0603_1608Metric
D8, D9: LED; LED_0603_1608Metric
FB1, FB2: Ferrite_Bead_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
J2: Conn_02x03_Odd_Even; PinHeader_2x03_P1.27mm_Vertical_SMD
J3: USB_C_Receptacle; USB_C_Receptacle_Amphenol_12401610E4-2A
J4, J11: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J5: 3220-10-0100-00
J6: Conn_01x24; Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal
J7, J8, J9, J10: Conn_01x20; PinHeader_1x20_P1.00mm_Vertical
JP1, JP2, JP6, JP7, JP8, JP9: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3, JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2, L3: 3.3uH; L_Bourns-SRN4018
Q1, Q2: MMBT3904; SOT-23
R1, R29: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R9: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R21: 1k; R_0603_1608Metric
R10, R24: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14: 47k; R_0603_1608Metric
R15, R16, R19, R20, R25, R40: 4.7k; R_0603_1608Metric
R17, R22: 220; R_0603_1608Metric
R18: 200k; R_0603_1608Metric
R23: 100; R_0603_1608Metric
R30: 31k; R_0603_1608Metric
R31, R33, R35, R37, R39, R41: 10k; R_0603_1608Metric
R32: 13k; R_0603_1608Metric
R34: 65k; R_0603_1608Metric
R36: 32.5k; R_0603_1608Metric
R38: 7.5k; R_0603_1608Metric
SW1, SW2: SW_Push; TS204225WT160SMTTR
SYM*1: devkits_qr
TP1: TestPoint; TestPoint_Pad_D1.0mm
TP2: 5v0; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP3: 3v3; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP4: 1v8; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP5: 0v8; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP6: GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: ESP32-C3-MINI-1
U2: FT2232HL-REEL; QFP50P1200X1200X160-64N
U3: W25Q32JWZP; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U4: FXMA2102UMX
U5, U15, U16: MP6400DG-01-LF-Z; QFN6_MP6400_MNP
U6, U7, U8, U9, U10, U13: NTB0104BQ,115; NXP_Semiconductors-SOT762-1-08_2019-0-MFG
U11: MCP9808; DFN-8-1EP_3x2mm_P0.5mm_EP1.7x1.4mm
U12: AP2127K-2.8; SOT-23-5
U14: CORE-V-MCU; LQFP-80_12x12mm_P0.5mm
U23, U24, U25: AP62300Z6; SOT-563
X1: ECS-2520MVLC-100-CN; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
Y1: 32.768kHz; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm_HandSolder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
Y2: 12MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
10MHZ_CLOCK_SOC: J9.8, U14.48 (IO5), X1.3 (OUT)
+0V8: C77.1, C80.1, C83.1, C84.1, C85.1, C86.1, C87.1, J7.11, J7.13, J8.13, J8.15, J9.11, J9.13, J10.11, J10.13, L3.2, R38.1, TP5.1, U14.11 (VDDC), U14.13 (VDD_FPGA), U14.33 (VDDC), U14.35 (VDD_FPGA), U14.51 (VDDC), U14.53 (VDD_FPGA), U14.71 (VDDC), U14.73 (VDD_FPGA), U25.6 (FB)
+1V8: C28.1, C41.1, C45.1, C49.1, C55.1, C57.1, C59.1, C61.1, C63.1, C65.1, C76.1, C79.1, C82.1, J5.1, J6.10, J7.12, J8.3, J8.5, J8.14, J9.12, J10.12, JP2.1 (A), JP8.1 (A), L2.2, R15.2, R16.2, R25.2, R29.2, R32.1, R36.1, R41.2, TP4.1, U3.8 (VCC), U4.8 (VCCB), U6.1 (VCC(A)), U6.8 (OE), U7.1 (VCC(A)), U7.8 (OE), U8.1 (VCC(A)), U8.8 (OE), U9.1 (VCC(A)), U9.8 (OE), U10.1 (VCC(A)), U13.1 (VCC(A)), U14.12 (VDDIOC), U14.23 (AVDD2), U14.25 (AVDD), U14.34 (VDDIOC), U14.52 (VDDIOC), U14.72 (VDDIOC), U15.1 (VCC), U16.1 (VCC), X1.1 (Tri-State), X1.4 (VDD)
+3V3: C3.1, C4.1, C9.1, C14.1, C15.1, C16.1, C17.1, C29.1, C32.1, C33.1, C35.1, C36.1, C40.1, C48.1, C50.1, C68.1, C75.1, C78.1, C81.1, CON1.P7 (3V3), D8.2 (A), D9.2 (A), FB1.1, FB2.1, J2.2, JP1.1 (A), JP3.2 (B), JP4.2 (B), JP5.2 (B), L1.2, R1.1, R5.1, R6.2, R7.2, R9.2, R14.1, R18.2, R19.2, R20.2, R30.1, R34.1, R40.2, TP3.1, U1.3 (3V3), U2.20 (VCCIO-1), U2.31 (VCCIO-2), U2.42 (VCCIO-3), U2.50 (VREGIN), U2.56 (VCCIO-4), U5.1 (VCC), U6.14 (VCC(B)), U7.14 (VCC(B)), U8.14 (VCC(B)), U9.14 (VCC(B)), U10.14 (VCC(B)), U11.8 (VDD), U12.1 (VIN), U12.3 (EN), U13.14 (VCC(B))
+5V: C5.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, D3.C, TP2.1, U23.1 (VIN), U24.1 (VIN), U25.1 (VIN)
/CLICK_CS: CON1.P3 (CS), U7.10 (B4)
/CLICK_INT: CON1.P15 (INT), U8.12 (B2)
/CLICK_MISO: CON1.P5 (MISO), U7.12 (B2)
/CLICK_MOSI: CON1.P6 (MOSI), U7.13 (B1)
/CLICK_PWM: CON1.P16 (PWM), U8.13 (B1)
/CLICK_RST: CON1.P2 (RST), U6.10 (B4)
/CLICK_RX: CON1.P14 (RX), U8.11 (B3)
/CLICK_SCK: CON1.P4 (SCK), U7.11 (B3)
/CLICK_TX: CON1.P13 (TX), U8.10 (B4)
/EL_EVENT: U1.16 (GPIO10), U6.13 (B1)
/EL_RXD: U1.27 (GPIO19/USB_D+), U6.11 (B3)
/EL_TXD: U1.26 (GPIO18/USB_D-), U6.12 (B2)
/EL_WAKE: U1.6 (GPIO3/ADC1_CH3), U9.11 (B3)
/Power Supply/~RESET_IN: R40.1, SW2.2, U5.4 (*MR)
/camera/2v8: C37.1, J6.4, J6.11, U12.5 (VOUT)
/jtag and uart/VBUS: D1.1 (A1), D3.A, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
/jtag and uart/d+: D4.1 (A1), J3.A6 (D+), J3.B6 (D+), U2.8 (DP)
/jtag and uart/d-: D2.1 (A1), J3.A7 (D-), J3.B7 (D-), U2.7 (DM)
/jtag and uart/shield: C27.1, C30.1, J3.S1 (SHIELD), R24.1
/mikrobus and sensors/temperature_alert: R14.2, U11.3 (Alert)
/~EL_RESET: C34.1, R1.2, U1.8 (EN/CHIP_PU), U9.10 (B4)
BOOTSEL: J8.19, J11.1, R41.1, U14.39 (IO45)
CAMERA_D0: J6.14, J10.6, U14.66 (IO29)
CAMERA_D1: J6.3, J10.17, U14.77 (IO30)
CAMERA_D2: J6.9, J10.14, U14.74 (IO31)
CAMERA_D3: J6.5, J10.16, U14.76 (IO32)
CAMERA_D4: J6.12, J10.8, U14.68 (IO33)
CAMERA_D5: J6.20, J10.3, U14.63 (IO34)
CAMERA_D6: J6.19, J10.4, U14.64 (IO35)
CAMERA_D7: J6.13, J10.7, U14.67 (IO36)
CAMERA_HSYNC: J6.16, J9.19, U14.59 (IO22)
CAMERA_MCLK: J6.8, J10.15, U14.75 (IO26)
CAMERA_PCLK: J6.17, J10.5, U14.65 (IO25)
CAMERA_VSYNC: J6.6, J9.20, U14.60 (IO21)
CLICK_IRQ_SOC: J8.18, U8.3 (A2), U14.38 (IO37)
CLICK_PWM_SOC: J8.20, U8.2 (A1), U14.40 (IO42)
CLICK_RESET_SOC: J7.5, U6.5 (A4), U14.5 (IO18)
CONSOLE_RX: U2.52 (BCBUS1), U9.13 (B1)
CONSOLE_TX: U2.48 (BCBUS0), U9.12 (B2)
CS0_SOC: J10.20, U7.5 (A4), U14.80 (IO38)
EL_EVENT_SOC: J9.18, U6.2 (A1), U14.58 (IO24)
EL_WAKE_SOC: J9.17, U9.4 (A3), U14.57 (IO23)
FPGA_LED0: J10.18, R21.2, U14.78 (IO28)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C40.2, C41.2, C45.2, C48.2, C49.2, C50.2, C55.2, C57.2, C59.2, C61.2, C63.2, C65.2, C68.2, C69.2, C70.2, C71.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, CON1.P8 (GND1), CON1.P9 (GND2), D1.2 (A2), D2.2 (A2), D4.2 (A2), J1.3, J1.5, J1.7, J1.9, J2.4, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J4.2, J5.3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
MISO0_SOC: J8.9, U7.3 (A2), U14.29 (IO41)
MOSI0_SOC: J8.10, U7.2 (A1), U14.30 (IO39)
NB: C25.2, J9.1, JP7.2 (B), U14.41 (NB)
unnamed: C31.1, R23.1, R25.1, SW1.2
unnamed: D5.2 (A), R6.1
unnamed: D5.1 (K), U2.41 (BDBUS3)
unnamed: D6.2 (A), R7.1
unnamed: D6.1 (K), U2.43 (BDBUS4)
unnamed: D7.2 (A), R9.1
unnamed: D7.1 (K), U2.29 (ACBUS3)
unnamed: D8.1 (K), R17.2
unnamed: D9.1 (K), R22.2
unnamed: J1.1, JP1.2 (B)
unnamed: J1.2, U1.18 (GPIO4/ADC1_CH4)
unnamed: J1.4, U1.20 (GPIO6)
unnamed: J1.6, U1.21 (GPIO7)
unnamed: J1.8, U1.19 (GPIO5/ADC2_CH0)
unnamed: J2.3, U1.31 (GPIO21/U0TXD)
unnamed: J2.5, U1.30 (GPIO20/U0RXD)
unnamed: J3.A5 (CC1), R3.1
unnamed: J3.B5 (CC2), R2.1
unnamed: J4.1, R29.1, U10.8 (OE), U13.8 (OE)
unnamed: JP3.1 (A), R11.1, U11.5 (A2)
unnamed: JP4.1 (A), R12.1, U11.6 (A1)
unnamed: JP5.1 (A), R13.1, U11.7 (A0)
unnamed: Q1.1 (B), R8.1
unnamed: Q1.3 (C), R17.1
unnamed: Q2.1 (B), R21.1
unnamed: Q2.3 (C), R22.1
unnamed: C1.1, R10.1, U1.12 (GPIO0/ADC1_CH0/XTAL_32K_P), Y1.1
unnamed: C2.1, R10.2, U1.13 (GPIO1/ADC1_CH1/XTAL_32K_N), Y1.2
unnamed: R4.1, U2.6 (REF)
unnamed: C18.1, C19.1, C20.1, C26.1, U2.12 (VCORE-1), U2.37 (VCORE-2), U2.49 (VREGOUT), U2.64 (VCORE-3)
unnamed: C10.1, C12.1, FB1.2, U2.4 (VPHY)
unnamed: C11.1, C13.1, FB2.2, U2.9 (VPLL)
unnamed: R5.2, U2.14 (~RESET)
unnamed: C6.1, R18.1, U4.1 (VCCA), U4.5 (OE)
unnamed: C21.1, U5.3 (CDELAY)
unnamed: R34.2, R35.1, U5.2 (SENSE)
unnamed: U2.17 (ADBUS1), U10.13 (B1)
unnamed: U2.18 (ADBUS2), U10.12 (B2)
unnamed: U2.16 (ADBUS0), U10.11 (B3)
unnamed: U2.19 (ADBUS3), U10.10 (B4)
unnamed: U2.23 (ADBUS6), U13.10 (B4)
unnamed: U5.6 (*RESET), U15.4 (*MR)
unnamed: U15.6 (*RESET), U16.4 (*MR)
unnamed: C22.1, U15.3 (CDELAY)
unnamed: R36.2, R37.1, U15.2 (SENSE)
unnamed: C23.1, U16.3 (CDELAY)
unnamed: R38.2, R39.1, U16.2 (SENSE)
unnamed: L1.1, U23.4 (BST)
unnamed: R30.2, R31.1, U23.6 (FB)
unnamed: C72.2, U23.2 (SW)
unnamed: L2.1, U24.4 (BST)
unnamed: R32.2, R33.1, U24.6 (FB)
unnamed: C73.2, U24.2 (SW)
unnamed: L3.1, U25.4 (BST)
unnamed: C74.2, U25.2 (SW)
PB: C25.1, J9.2, JP8.2 (B), U14.42 (PB)
PGM_FLASH_CLK: J7.15, U3.6 (CLK), U14.15 (IO16)
PGM_FLASH_CS: J7.8, U3.1 (~CS), U14.8 (IO13)
PGM_FLASH_DATA0: J7.16, U3.5 (DI(IO0)), U14.16 (IO14)
PGM_FLASH_DATA1: J7.7, U3.2 (DO(IO1)), U14.7 (IO15)
PGM_FLASH_DATA2: J7.6, U3.3 (IO2), U14.6 (IO19)
PGM_FLASH_DATA3: J7.14, U3.7 (IO3), U14.14 (IO20)
POWER_DETECT: J9.14, TP1.1, U14.54 (POWER_DETECT)
RX1_MUX0_SOC: J7.4, U6.3 (A2), U14.4 (IO12)
RX1_MUX1_SOC: J7.20, U8.4 (A3), U14.20 (IO10)
SCL: CON1.P12 (SCL), R19.1, U4.2 (A0), U11.2 (SCL)
SCL0_SOC: J6.21, J10.1, R15.1, U4.7 (B0), U14.61 (IO46)
SCLK0_SOC: J8.8, U7.4 (A3), U14.28 (IO40)
SDA: CON1.P11 (SDA), R20.1, U4.3 (A1), U11.1 (SDA)
SDA0_SOC: J6.22, J10.2, R16.1, U4.6 (B1), U14.62 (IO47)
TCK: J5.4, J9.4, U10.4 (A3), U14.44 (IO0)
TDI: J5.8, J9.6, U10.2 (A1), U14.46 (IO1)
TDO: J5.6, J9.5, U10.3 (A2), U14.45 (IO2)
TEST_MODE: J8.17, JP9.1 (A), U14.37 (IO44)
TMS: J5.2, J9.3, U10.5 (A4), U14.43 (IO3)
TRST: J5.10, J9.7, U13.5 (A4), U14.47 (IO4)
TX0_RXD: J7.17, U9.3 (A2), U14.17 (IO7)
TX0_TXD: J7.18, U9.2 (A1), U14.18 (IO8)
TX1_MUX0_SOC: J7.3, U6.4 (A3), U14.3 (IO11)
TX1_MUX1_SOC: J7.19, U8.5 (A4), U14.19 (IO9)
USER_BUTTON: J9.16, R23.2, U14.56 (IO17)
USER_LED_SOC: J8.16, R8.2, U14.36 (IO27)
VNW_N: C24.2, J7.2, JP6.2 (B), U14.2 (VNW_N)
VPW_P: C24.1, J7.1, JP2.2 (B), U14.1 (VPW_P)
osci: C8.1, U2.2 (OSCI), Y2.1
osco: C7.1, U2.3 (OSCO), Y2.3
~EL_RESET_SOC: J10.19, U9.5 (A4), U14.79 (IO43)
~RESET_SOC: J9.15, U14.55 (IO6), U16.6 (*RESET)

## Commit log

2022-03-10 OpenHW Group License file
2022-03-10 OpenHW CodeOfConduct
2022-03-10 OpenHW Group Contributing rules
2022-03-10 Update to exclude core-v-verif content
2022-03-10 ignoring the backups folder
2022-03-11 additional sheets added
2022-03-15 updates to the jtag interface
2022-03-15 Edits to JTAG
2022-03-16 updates jtag sheet
2022-03-16 adjustments
2022-03-16 added logs and 3d model updates
2022-06-14 updates to the images and place holders for MCU footprint
2022-07-27 added solderpad license text to each sheet
2022-08-27 added the camera, temperature sensor and basic MCU symbol
2022-09-09 MCU pinout finalized
2022-10-07 Power and Level Shifter updates
2022-10-07 updates to the footprints
2022-10-13 pcb updates including level shifter adjustments
2022-10-13 sync with schematic
2022-10-18 Update bottom and right edges of board wiring
    Place components along bottom and right edge of board.
2022-10-20 Rework the SOC pinout
2022-10-26 New pinout (old symbol)
2022-10-29 revised pinout
2023-02-22 Changed to KiCAD 7 and updated to final pinout.
2023-02-22 Updated camera and button models
2023-02-22 added pin numbers to the test ring
2023-02-24 reset supervisor replacement and DRC cleanup
2023-02-24 removing old backup files
2023-02-24 removed remaining backups zip files
2023-02-24 Updated gitignore to ignore backups
2023-03-02 updated pinout changes
2023-03-02 updated some text and removed an old picture
2023-03-03 updated the QR code and added shield coupling to the usb connector
2023-03-09 adjusted track spacing and cleared DRC
2023-03-29 routed the Opella changes
2023-03-29 pullup resistors on JTAG signals
2023-04-03 swapped bootsel & test_mode pins
2023-04-20 updated footprints, added the barrel power connector and test points
2023-04-20 updated 3d models and cleaned up the DRC
2023-05-20 Converted from QFP to BGA
2023-05-22 added BGA 3d model and corrected click connector
2023-05-22 Adding a 3d image
2023-05-26 Grounded the die paddle
2023-07-20 Added PDF and corrected AVDD net
2023-07-25 updated the graphics and moved files around for neatness
2023-07-26 minor save
2023-07-26 moved kicad files to the kicard folder
2023-07-26 moved the project parts folder into the kicad folder
2023-07-26 ignoring kicad backups and adding more content to the readme
2023-08-04 Add Devkit block diag
2023-08-07 Use symantic versioning for the E40P.
2023-08-16 create basic docs structure as copy from Core-V-MCU
2023-08-16 Create basic read the docs structure
2023-08-17 Various fixes to the .rst files, addition of yaml
2023-08-17 add build os to the .yaml file and fix the file name for python requirements
2023-08-17 .yaml file update
2023-08-18 Initial content for hardware overview + moving images under docs
2023-08-23 Refer to "Open Source Development at OpenHW"
    This PR removes the "Open Source Development at OpenHW" section and adds a link to the content in the `programs` repo.
2023-08-24 changes to the readme and added some images including the schematic
2023-08-24 directly grounded the USB shield
2023-09-06 Basic software docs structure + updated DevKit images
2023-09-06 Added a basic shell for ePGA documentation
2023-09-06 update index file
2023-09-12 Replaced TAB in index.rst
2023-09-13 change efpga file name in index.rst to lower case
2023-09-23 Added the CORE-V Pinout as used by the devkit.
2023-10-25 Corections made after testing V1
2024-01-31 changes to the power supply and minor edits to the silkscreen

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
